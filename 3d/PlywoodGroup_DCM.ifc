Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-12-21T13:17:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 21 13:17:10 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{648533D8-85A9-4AD3-85E5-B7000B1075D7}\ifc * Database version: 5507 * Database creation date: Fri Dec 21 13:17:09 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Dec 21 13:17:09 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 21 13:17:09 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Plywood Group DCM, CONV_Vitra_DmstcChrs_PlywoodGroup_DCM:Plywood Group DCM:349803
In: Level 1
Material: 64 Ash natural, Plastic black, 01 chrome
Pset_ManufacturerTypeInformation - ModelReference: 21054600; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.08477 m2; Volume: 0.213867 m3
Materials and Finishes - ChairMainMaterial: 64 Ash natural; ChairSecondaryMaterial: 01 chrome
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: CONV_Vitra_DmstcChrs_PlywoodGroup_DCM: Plywood Group DCM; Family and Type: CONV_Vitra_DmstcChrs_PlywoodGroup_DCM: Plywood Group DCM; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: CONV_Vitra_DmstcChrs_PlywoodGroup_DCM: Plywood Group DCM; Type Id: CONV_Vitra_DmstcChrs_PlywoodGroup_DCM: Plywood Group DCM; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
General(Type) - Author: Convergo AB; BIMObjectName: CONV_Vitra_DmstcChrs_PlywoodGroup_DCM; ConvergoRefNr: 0089-1812-0159-CH; ManufacturerName: Vitra; ManufacturerURL: www.vitra.com; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: Charles and Ray Eames spent many years experimenting with new techniques for producing three-dimensionally moulded plywood seat shells that conformed to the contours of the human body. They achieved this with the chairs in the Plywood Group, which have matured into classics with an appearance that still looks contemporary today. For the Plywood Group, they also combined the seats and backs with different bases. Thanks to the organic shape of the plywood shells and the slightly flexible backrests, these light and compact chairs are extremely comfortable – also in the versions without upholstery.; Revision: n/a; Uniclass2: Pr_40_50_12_22; Uniclass2015Description: Dining chairs; Uniclass2015Reference: Pr_40_50_12_22; Version: 1; VersionDate: 20/12/2018
Identity Data(Type) - Collection: Plywood Group; Cost: 0; Description: Charles and Ray Eames spent many years experimenting with new techniques for producing three-dimensionally moulded plywood seat shells that conformed to the contours of the human body. They achieved this with the chairs in the Plywood Group, which have matured into classics with an appearance that still looks contemporary today. For the Plywood Group, they also combined the seats and backs with different bases. Thanks to the organic shape of the plywood shells and the slightly flexible backrests, these light and compact chairs are extremely comfortable – also in the versions without upholstery.; Designer: Charles & Ray Eames; Manufacturer: Vitra; Model: Plywood Group DCM; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: https://www.vitra.com/en-cz/_storage/asset/356984/storage/master/download/Factsheet%20Plywood%20Group%20Chairs-EN.pdf; Type Name: Plywood Group DCM; URL: https://www.vitra.com/en-cz/product/plywood-group
Materials and Finishes(Type) - ChairTertiaryMaterial: Plastic black
Other(Type) - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Chairs; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: CONV_Vitra_DmstcChrs_PlywoodGroup_DCM; Features: n/a; Finish: Veneered wood, chrome-plated or powder-coated steel; Grade: n/a; Material: Plywood, steel; ModelNumber: n/a; ModelReference: 21054600; Name: DmstcChrs_PlywoodGroup_DCM; ReplacementCost: n/a; Shape: Sculptured; Size: 515x565x735 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
